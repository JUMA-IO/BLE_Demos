# Keil uVision project Project.uvprojx, settings and files
target STM32L1xx_Nucleo (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1
  c define: STM32L152xE USE_STM32L1XX_NUCLEO USE_HAL_DRIVER
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Middlewares\ST\STM32_Serial_Utility_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps25h;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Src
    ../../Src/: com.c DemoSerial.c Env_SerialCmd_Handlers.c main.c MEMS_SerialCmd_Handlers.c cube_hal_l1.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../../../Drivers/BSP/Components/lps25h/: lps25h.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: lps25hb.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: lsm6ds0.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: lsm6ds3.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c
  group Middlewares/STM32_Serial_Utility_Library
    ../../../../../../Middlewares/ST/STM32_Serial_Utility_Library/Src/: serial_protocol.c
  group Example/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xe.s
software components: CMSIS:CORE 4.1.0
