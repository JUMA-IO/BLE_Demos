# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\Middlewares\ST\STM32_Serial_Utility_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lps25h; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../../../Drivers/BSP/Components/lps25h/: lps25h.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: lps25hb.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: lsm6ds0.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: lsm6ds3.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: com.c cube_hal_f4.c DemoSerial.c Env_SerialCmd_Handlers.c main.c MEMS_SerialCmd_Handlers.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Middlewares/STM32_Serial_Utility_Library
    ../../../../../../Middlewares/ST/STM32_Serial_Utility_Library/Src/: serial_protocol.c
