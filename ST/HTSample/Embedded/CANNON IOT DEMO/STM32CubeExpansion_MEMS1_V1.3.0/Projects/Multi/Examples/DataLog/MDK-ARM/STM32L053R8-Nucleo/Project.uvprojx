# Keil uVision project Project.uvprojx, settings and files
target STM32L0xx-Nucleo (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Middlewares\ST\STM32_Serial_Utility_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps25h;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ../../Src/: com.c cube_hal_l0.c DemoSerial.c Env_SerialCmd_Handlers.c main.c MEMS_SerialCmd_Handlers.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../../../Drivers/BSP/Components/lps25h/: lps25h.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: lps25hb.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: lsm6ds0.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: lsm6ds3.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/STM32_Serial_Utility_Library
    ../../../../../../Middlewares/ST/STM32_Serial_Utility_Library/Src/: serial_protocol.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
software components: CMSIS:CORE 3.40.0
