# Keil uVision project BlueNRG_SDK.uvproj, settings and files
target Blue_NRG_MS_F4xx_SDK (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: BlueNRG_SDK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_CANON,ENABLE_SPI_FIX,BLUENRG_MS
  c misc: --C99 --gnu
  c include: ..\..\..\..\..\Drivers\BSP\BlueNRG_MS;..\..\..\..\..\Drivers\BSP\STM32F401RE;..\..\..\..\..\Drivers\CMISS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\CMISS\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Middlewares\ST\LowPowerManager\Inc;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\STM32F4xx_HAL_BlueNRG_Drivers\inc;..\..\..\..\..\Middlewares\ST\TimerServer\inc;..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../SW4STM32/: startup_stm32f401xe.s
  group Application/User
    ../Src/: bluenrg_interface.c canon_hal_f4.c clock.c stm32xx_it.c bluenrg_sdk_api.c main.c
    ../../Echo/: demo_echo.c
  group Drivers/BSP/STM32F4RE
    ../../../../../Drivers/BSP/STM32F401RE/: stm32f4xx_canon.c
  group Drivers/BSP/BlueNRG_MS
    ../../../../../Drivers/BSP/BlueNRG_MS/: stm32_bluenrg_ble.c
  group Drivers/CMISS
    ../../../../../Drivers/CMISS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ex.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c osal.c
