# Keil uVision project Project.uvprojx, settings and files
target Blue_NRG_MS_F4xx_SDK (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_CANON,ENABLE_SPI_FIX,BLUENRG_MS
  c misc: --C99 --gnu
  c include: ..\..\..\..\..\Drivers\BSP\BlueNRG_MS;..\..\..\..\..\Drivers\BSP\STM32F401RE;..\..\..\..\..\Drivers\CMISS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Middlewares\ST\LowPowerManager\Inc;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\STM32F4xx_HAL_BlueNRG_Drivers\inc;..\..\..\..\..\Middlewares\ST\TimerServer\inc;..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc;..\..\..\..\..\..\ST_SDK;..\Inc;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\Drivers\BSP\Components\Common;..\app;..\..\Sdk\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/app
    ../app/: app.c
  group Application/Sdk
    ../../Sdk/Src/: bluenrg_sdk_api.c bluenrg_interface.c canon_hal_f4.c clock.c
    ../Src/: main.c stm32xx_it.c
  group Drivers/BSP/STM32F4RE
    ../../../../../Drivers/BSP/STM32F401RE/: stm32f4xx_canon.c
  group Application/SW4STM32
    ../../Sdk/SW4STM32/: startup_stm32f401xe.s
  group Drivers/BSP/BlueNRG_MS
    ../../../../../Drivers/BSP/BlueNRG_MS/: stm32_bluenrg_ble.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group Drivers/CMISS
    ../../../../../Drivers/CMISS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c osal.c
software components: CMSIS:CORE 4.1.0
